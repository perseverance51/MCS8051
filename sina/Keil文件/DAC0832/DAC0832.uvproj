# Keil uVision project DAC0832.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC12C5A16S2 STC12C5A16S2 Series
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0x3FFF) CLOCK(45000000) MODP2
  output: DAC0832 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 DAC0832.C
