# Keil uVision project 12864LCD显示计算器键盘按键.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 12864LCD显示计算器键盘按键 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Keil C
  group Source Group 1
    ./: MAIN.C LCD_12864.C KeyPad.c DotMatri.H
