# Keil uVision project STC15USART.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: STC15USART +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\STC15USART _PWM
  group Source Group 1
    ./: main.c USART.c config.h PWM.C ADC.C
