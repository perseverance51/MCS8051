# Keil uVision project 程序.uvproj, settings and files
target 数控直流电压源 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: 程序 +hex
  c flags: Optimize=8 SizeSpeed=1
  group 程序
    ./: main.c
