# Keil uVision project 1602LCD+24C04电子密码锁.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51RB2 Atmel
  cpu: IRAM(0 - 0xFF) IROM(0-0x3FFF) XRAM(0 - 0xFF) CLOCK(60000000) MODP2
  output: 1602LCD+24C04电子密码锁 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: 1602LCD+24C04电子密码锁.c
