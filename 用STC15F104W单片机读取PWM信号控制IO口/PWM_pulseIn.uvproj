# Keil uVision project PWM_pulseIn.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F104W Series STC
  cpu: IRAM(0-0x7F) IROM(0-0xFF8) CLOCK(35000000)
  output: PWM_pulseIn
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c
