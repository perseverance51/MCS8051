# Keil uVision project lcd1602iic.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: lcd1602iic +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: lcd1602iic.c delay.c
