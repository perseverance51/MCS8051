# Keil uVision project LCD1602_driver.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x1FFF) CLOCK(24000000)
  output: LCD1602_driver +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\STC15+LCD1602+DS1302驱动显示程序
  group Source Group 1
    ./: main.c DS1302.c
