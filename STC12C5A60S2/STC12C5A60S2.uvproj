# Keil uVision project STC12C5A60S2.uvproj, settings and files
target STC12C5A60S2 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: STC12C5A60S2 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source
    ./: STC12C5A60S2.c
