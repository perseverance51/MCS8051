# Keil uVision project aa.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: aa +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\lcd12864_catpoo-master
  group Source Group 1
    ./: main.c LCD12864.c font.h delay.c
