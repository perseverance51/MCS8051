# Keil uVision project DS1302_LCD1602.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: DS1302_LCD1602 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\inc
  group Source Group 1
    ./src/: DS1302.c Lcd1602.c
    ./: main.c
