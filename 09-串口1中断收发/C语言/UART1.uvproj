# Keil uVision project UART1.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W408AS Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FF8) CLOCK(35000000) MODP2
  output: UART1 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\C语言
  group Source Group 1
    ./: main.c
