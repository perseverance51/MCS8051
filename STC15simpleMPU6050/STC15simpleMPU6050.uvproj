# Keil uVision project STC15simpleMPU6050.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W408AS Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FF8) CLOCK(35000000) MODP2
  output: STC15simpleMPU6050 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\STC15simpleMPU6050
  group Source Group 1
    ./: 51-串口-mpu6050.c
