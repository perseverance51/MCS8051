# Keil uVision project BST-V51.uvproj, settings and files
target 目标 1 (MCS-51)
  device: STC15W408AS Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FF8) CLOCK(35000000) MODP2
  output: RECE_IR +hex
  c flags: Optimize=8 SizeSpeed=1
  group 源代码组 1
    ./: main.c
